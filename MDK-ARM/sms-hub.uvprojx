# Keil uVision project sms-hub.uvprojx, settings and files
target sms-hub (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sms-hub +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -Os -ffunction-sections -fdata-sections -std=c99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP;../App;../App/menu;../App/tasks;../Drivers_Device/cs100a;../Drivers_Device/dht11;../Drivers_Device/ec11;../Drivers_Device/eventlog;../Drivers_Device/kvstore;../Drivers_Device/mq_gas;../Drivers_Device/oled_ssd1306;../Drivers_Device/oled_ui;../Drivers_Device/radar_at6010;../Drivers_Device/sg90;../Drivers_Device/tb6612_fan;../Drivers_Device/w25q64;../Middleware/esp8266;../Middleware/filter;../Middleware/json_mini;../Middleware/mqtt_client;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/portable/ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --remove
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: bsp_board.c bsp_timer_us.c
  group M1
    ../BSP/: bsp_analog_rtc.c bsp_bus.c bsp_console.c bsp_controls.c
    ../App/tasks/: app_tasks.c
    ../Middleware/FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
    ../Middleware/FreeRTOS/portable/: heap_4.c
    ../Middleware/FreeRTOS/portable/ARM_CM3/: port.c
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_iwdg.c
software components: CMSIS:CORE 4.3.0
